# Keil uVision project motor_extMode.uvprojx, settings and files
target motor_extMode (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: motor_extMode +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MEM_UNIT_BYTES,ARM_MATH_CM4,MemUnit_T=uint8_T,MATLAB_PROJECT,EXT_MODE=1,EXTMODE_DISABLEPRINTF,EXTMODE_DISABLETESTING,EXTMODE_DISABLE_ARGS_PROCESSING=1,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;     ../Drivers/CMSIS/Include;     ../motor/Inc;     "../../../../../../Program Files/MATLAB/R2020a/extern/include";     "../../../../../../Program Files/MATLAB/R2020a/simulink/include";     "../../../../../../Program Files/MATLAB/R2020a/rtw/c/src";     "../../../../../../Program Files/MATLAB/R2020a/rtw/c/src/ext_mode/common";     "../../../../../../Program Files/MATLAB/R2020a/rtw/c/ert";     "../../../../../../Program Files/MATLAB/R2020a/toolbox/coder/rtiostream/src";     "../../../../../../Program Files/MATLAB/R2020a/toolbox/coder/rtiostream/src/utils";     "../../../../../../Program Files/MATLAB/R2020a/rtw/c/src/ext_mode/serial";     ../../../../../../MATLAB/STM32-MAT/STM32/addSrc/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group MATLAB
    C:/MATLAB/STM32-MAT/STM32/addSrc/src/: getBuffPtr.c
    C:/Users/tuziz/Desktop/STM Projects/Matlab DC MOTOR/motor/Src/: STM32SerialRtiostream.c ext_svr.c ext_work.c updown.c rtiostream_utils.c motor.c motor_TIM.c motor_data.c ext_serial_pkt.c rtiostream_serial_interface.c ext_svr_serial_transport.c
software components: CMSIS:CORE 4.3.0
